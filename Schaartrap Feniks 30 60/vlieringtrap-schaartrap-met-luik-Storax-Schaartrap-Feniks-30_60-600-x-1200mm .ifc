Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 382308ac-78a2-43a1-967f-ebaf7b662110.ifc
Time: 2026-08-11T15:59:26
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcStair, vlieringtrap schaartrap met luik Storax - Schaartrap Feniks 30/60 600 x 1200mm
In: Bouwlaag
Material: aluminium
Pset_Data - WUID: AgAAADMiBUAGAAAA_esCAAWxXwAAPHsBAHQGAACl6wIAsusCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIApOwCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAADMiBUAGAAAA_esCAAWxXwAAPHsBAHQGAACl6wIAsusCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIApOwCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); STABU2: 32.32.11; lengte: 1180 mm; inbouwhoogte: 240 mm; inbouwlengte: 1200 mm; U-waarde: 0,57 w/m²·k; breedte: 580 mm; max. belasting: 200 kg; NAA.K.T: samengesteld_product_generiek; bediening: handmatig; theoretische levensduur: 50; serie: Schaartrap Feniks 30/60; inbouwbreedte: 600 mm; merk: Storax; beweegbaar: True; omranding: staal; luik: staal; trap: schaarladder Storax - Schaarladder 200mm
